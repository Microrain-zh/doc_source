# Keil uVision project F103_Moduel.uvprojx, settings and files
target F103_Moduel (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: F103_Moduel +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\ModuleDrivers;../smartdevice/cal;../smartdevice/kal;../smartdevice/input;../smartdevice/unittest;../smartdevice/device;../smartdevice/device/display;../smartdevice/config;../smartdevice/fonts;../smartdevice/text;../smartdevice/net;../smartdevice/device/uart;../smartdevice/smarthome
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group ModuleDrivers
    ../ModuleDrivers/: driver_usart.c ring_buffer.c driver_key.c driver_led.c driver_i2c.c driver_oled.c driver_fan.c
  group kal
    ../smartdevice/kal/: kal_gpio_key.c kal_time.c kal_led_device.c kal_oled_device.c kal_uart_dev.c kal_fan_device.c
  group cal
    ../smartdevice/cal/: cal_gpio_key.c cal_time.c cal_led_device.c cal_oled_device.c cal_uart_dev.c cal_fan_device.c
  group input
    ../smartdevice/input/: gpio_key.c input_buffer.c input_system.c net_input.c
  group unittest
    ../smartdevice/unittest/: input_test.c led_test.c display_test.c text_test.c net_test.c fan_test.c
  group device
    ../smartdevice/device/: led_device.c fan_device.c
    ../smartdevice/device/uart/: uart_dev.c
  group display
    ../smartdevice/device/display/: display_device.c display_system.c oled_device.c
  group fonts
    ../smartdevice/fonts/: ascii_font.c font_manager.c font_system.c
  group text
    ../smartdevice/text/: show_text.c
    ../smartdevice/text/encoding/: encoding.c
  group net
    ../smartdevice/net/: esp8266.c net_device.c net_system.c
    ../smartdevice/net/at_command/: at_command.c
  group smarthome
    ../smartdevice/smarthome/: message.c smarthome.c
software components: CMSIS:CORE 4.3.0
